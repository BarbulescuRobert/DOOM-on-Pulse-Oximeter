# IAR project Template.ewp, settings and files
configuration APM32F030 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F030R8 Geehy APM32F030R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F030_MINI; APM32F030x8
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Boards; ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APM32F051 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F051R8 Geehy APM32F051R8
  ICCARM.CCDefines: BOARD_APM32F051_MINI; APM32F051x8
configuration APM32F072 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F072VB Geehy APM32F072VB
  ICCARM.CCDefines: BOARD_APM32F072_MINI; APM32F072xB
configuration APM32F091 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F091VC Geehy APM32F091VC
  ICCARM.CCDefines: BOARD_APM32F091_MINI; APM32F091xC
  group Application
    ../../Source/: apm32f0xx_int.c main.c
  group Board
    ../../../../../Boards/: Board.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f030.s startup_apm32f051.s startup_apm32f072.s startup_apm32f091.s
    ../../Source/: system_apm32f0xx.c
  group StdPeriphDriver
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
