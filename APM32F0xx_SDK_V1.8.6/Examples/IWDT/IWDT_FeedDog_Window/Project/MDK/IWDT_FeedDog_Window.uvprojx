# Keil uVision project IWDT_FeedDog_Window.uvprojx, settings and files
target APM32F030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F030R8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IWDT_FeedDog_Window
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F030_MINI,APM32F030x8
  c include: ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Boards;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_apm32f0xx.c
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f030.s startup_apm32f072.s
  group StdPeriphLib
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_eint.c apm32f0xx_gpio.c apm32f0xx_rcm.c apm32f0xx_usart.c apm32f0xx_misc.c apm32f0xx_iwdt.c
  group Board
    ../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c apm32f0xx_int.c
target APM32F072 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IWDT_FeedDog_Window
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F072_MINI,APM32F072xB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
