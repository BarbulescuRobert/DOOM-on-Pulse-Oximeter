<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CAN_DualFIFOPolling_Board1.ewp</path>
    </project>
    <batchBuild />
</workspace>
