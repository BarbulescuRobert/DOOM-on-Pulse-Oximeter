<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IAP_Application1.ewp</path>
    </project>
    <batchBuild />
</workspace>
