# IAR project IAP_BootLoader.ewp, settings and files
configuration APM32F072 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F072VB Geehy APM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F072_MINI; APM32F072xB
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Boards; ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: IAP_BootLoader.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APM32F030 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: APM32F030R8 Geehy APM32F030R8
  ICCARM.CCDefines: BOARD_APM32F030_MINI; APM32F030x8
  ILINK.IlinkIcfFile: IAP_BootLoader.icf
  group Application
    ../../Source/: apm32f0xx_int.c common.c main.c menu.c ymodem.c
  group Board
    ../../../../../Boards/: Board.c
  group Bsp
    ../../Source/: bsp_flash.c bsp_usart.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f030.s startup_apm32f072.s
    ../../Source/: system_apm32f0xx.c
  group StdPeriphDriver
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_crc.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
