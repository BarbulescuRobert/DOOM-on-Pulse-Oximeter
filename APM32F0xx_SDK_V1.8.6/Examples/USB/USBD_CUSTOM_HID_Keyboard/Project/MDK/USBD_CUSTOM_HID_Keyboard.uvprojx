# Keil uVision project USBD_CUSTOM_HID_Keyboard.uvprojx, settings and files
target APM32F072 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USBD_CUSTOM_HID_Keyboard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USB_DEVICE,BOARD_APM32F072_MINI,APM32F072xB
  c include: ..\..\Include;..\..\..\..\..\Boards;..\..\..\..\..\Boards\Board_APM32F072_MINI\inc;..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CustomHID\Inc;..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../Source/: system_apm32f0xx.c
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f072.s
  group StdPeriphLib
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c apm32f0xx_usb.c apm32f0xx_usb_device.c
  group Board
    ../../../../../Boards/: Board.c
    ../../../../../Boards/Board_APM32F072_MINI/src/: bsp_delay.c
  group Application
    ../../Source/: main.c apm32f0xx_int.c
  group Application/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_custom_hid_if.c
  group Application/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Middlewares/USB_Device_Library
    ../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../Middlewares/APM32_USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
