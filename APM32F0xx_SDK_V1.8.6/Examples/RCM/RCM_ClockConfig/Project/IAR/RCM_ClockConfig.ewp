# IAR project RCM_ClockConfig.ewp, settings and files
configuration APM32F072 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F072VB Geehy APM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F072_MINI; APM32F072xB
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Boards; ..\..\..\..\..\Boards\Board_APM32F030_MINI; ..\..\..\..\..\Boards\Board_APM32F072_MINI; ..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include; ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f0xx_int.c main.c
  group Board
    ../../../../../Boards/: Board.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f072.s
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
  group StdPeriphDriver
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_eint.c apm32f0xx_gpio.c apm32f0xx_misc.c apm32f0xx_rcm.c apm32f0xx_syscfg.c apm32f0xx_usart.c
